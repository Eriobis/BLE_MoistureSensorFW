# Keil uVision project BLE_MoistureSensor.uvprojx, settings and files
target Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: BlueNRG-1 STMicroelectronics
  pack: Keil.STBlueNRG-1_DFP.1.2.0
  cpu: IROM(0x10040000,0x28000) IRAM(0x20000000,0x6000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: BLE_MoistureSensor +hex
  AfterMake: fromelf.exe --bin Release\Objects\BLE_MoistureSensor.axf --output Release\Objects\\BLE_MoistureSensor.bin
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ SMPS_INDUCTOR=SMPS_INDUCTOR_10uH BLUENRG1_DEVICE HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ BLE_STACK_CONFIGURATION=BLE_STACK_BASIC_CONFIGURATION FORCE_CORE_TO_16MHZ
  c include: ..\..\inc;..\..\..\..\Library\hal\inc;..\..\..\..\Library\BlueNRG1_Periph_Driver\inc;..\..\..\..\Library\CMSIS\Device\ST\BlueNRG1\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Bluetooth_LE\inc;..\..\..\..\Library\BLE_Application\layers_inc;..\..\..\..\Library\BLE_Application\Utils\inc;..\..\..\..\Library\BLE_Application\OTA\inc;..\..\..\..\Library\SDK_Eval_BlueNRG1\inc
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x10040000 size 0x28000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: BlueNRG1.sct
  group HAL
    ../../../../Library/hal/src/: clock.c context_switch.s miscutil.c osal.c sleep.c
  group Library
    ../../../../Library/BlueNRG1_Periph_Driver/src/: BlueNRG1_adc.c BlueNRG1_dma.c BlueNRG1_flash.c BlueNRG1_gpio.c BlueNRG1_i2c.c BlueNRG1_mft.c BlueNRG1_pka.c BlueNRG1_rtc.c BlueNRG1_spi.c BlueNRG1_sysCtrl.c BlueNRG1_uart.c BlueNRG1_wdg.c misc.c
  group Stack
    ../../../../Library/Bluetooth_LE/library/: libbluenrg1_stack.a
    ../../../../Library/cryptolib/: libcrypto.a
    ../../../../Library/Bluetooth_LE/src/: stack_user_cfg.c
  group Startup
    ../../../../Library/CMSIS/Device/ST/BlueNRG1/Source/: system_bluenrg1.c
  group User
    ../../src/: BLE_Beacon_main.c BlueNRG1_it.c bsp.c
